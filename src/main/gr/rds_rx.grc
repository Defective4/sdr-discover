options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: rds_rx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '8'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: pilot_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '19020'
    low_cutoff_freq: '18980'
    samp_rate: '240000'
    type: complex_band_pass
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '1.0'
    gain: '1.0'
    ntaps: '151'
    samp_rate: '19000'
    sym_rate: 19000/8
  states: {}
- name: rrc_taps_manchester
  id: variable
  parameters:
    value: '[rrc_taps[n] - rrc_taps[n+8] for n in range(len(rrc_taps)-8)]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: sig
  id: variable_function_probe
  parameters:
    block_id: sigProbe
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '53'
    max_gain: '1000'
    rate: '2e-3'
    reference: '0.585'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate / decimation) / (2*math.pi*75000)
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: signal
    target: sig
  states: {}
- name: ctlPort
  id: parameter
  parameters:
    label: ctl_port
    type: intx
    value: '25557'
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: digital.constellation_bpsk().base()
    fmax: '0.002'
    fmin: '-0.002'
    loop_bw: 2*math.pi / 100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '16'
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      #
      # Copyright 2020 Free Software Foundation, Inc.
      #
      # This file is part of GNU Radio
      #
      # SPDX-License-Identifier: GPL-3.0-or-later
      #
      #

      from gnuradio import gr
      import pmt


      class msg_controller(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self, name="Message Controller", in_sig=None, out_sig=None)

              self.message_port_register_in(pmt.intern("source"))
              self.set_msg_handler(pmt.intern("source"), self.msg_handler)

          def callbacks(self, freq, freq_offset):
              self.cb = {
                  "freq": freq,
                  "freq_offset": freq_offset
              }

          def msg_handler(self, msg):
              if not pmt.is_pair(msg) or pmt.is_dict(msg) or pmt.is_pdu(msg):
                  gr.log.warn(
                      "Input message %s is not a simple pair, dropping" % repr(msg))
                  return
              key = pmt.to_python(pmt.car(msg))
              val = pmt.to_python(pmt.cdr(msg))
              if key in self.cb:
                  self.cb[key](val)

          def stop(self):
              return True
  states: {}
- name: fir_filter_xxx_2
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps_manchester
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 100000, 20000)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 57e3
    decim: '10'
    samp_rate: samp_rate / decimation
    taps: firdes.low_pass(1.0, samp_rate / decimation, 7.5e3, 5e3)
    type: fcc
  states: {}
- name: gain
  id: parameter
  parameters:
    label: gain
    type: eng_float
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: params
    bb_gain0: '20'
    freq0: freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: params
  id: parameter
  parameters:
    label: params
    type: str
    value: '""'
  states: {}
- name: probePort
  id: parameter
  parameters:
    label: probe_port
    type: intx
    value: '25556'
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate // decimation // 10
    interp: '19000'
    type: ccc
  states: {}
- name: rdsPort
  id: parameter
  parameters:
    label: rds_port
    type: intx
    value: '25555'
  states: {}
- name: rds_decoder_0
  id: rds_decoder
  parameters: {}
  states: {}
- name: rds_parser_0
  id: rds_parser
  parameters:
    pty_locale: '0'
  states: {}
- name: sigProbe
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: self.epy_block_0.callbacks(self.set_freq,self.set_freq_offset)
    section: main_after_start
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: '"tcp://0:"+str(ctlPort)'
    bind: 'True'
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://0:"+str(rdsPort)'
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_1
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://0:"+str(probePort)'
    timeout: '100'
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', freq_xlating_fir_filter_xxx_1_0, '0']
- [blocks_complex_to_mag_squared_0, '0', sigProbe, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_var_to_msg_0, msgout, zeromq_push_msg_sink_1, in]
- [digital_constellation_receiver_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', rds_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [fir_filter_xxx_2, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_xxx_1_0, '0', rational_resampler_xxx_1, '0']
- [osmosdr_source_0, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_1, '0', fir_filter_xxx_2, '0']
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_parser_0, out, zeromq_push_msg_sink_0, in]
- [zeromq_pull_msg_source_0, out, epy_block_0, source]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
