options:
  parameters:
    author: Defective4
    generate_options: no_gui
    id: fft_rx
    output_language: python
    run_options: run
    title: FFT Receiver
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 88e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 24e5
  states: {}
- name: args
  id: parameter
  parameters:
    label: args
    short_id: a
    type: str
    value: '""'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/fft_size
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: ctlPort
  id: parameter
  parameters:
    label: Control Port
    short_id: c
    type: intx
    value: '25555'
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: fft_size
    short_id: t
    type: intx
    value: '1024'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: gain
  id: parameter
  parameters:
    label: gain
    short_id: g
    type: intx
    value: '0'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: rxPort
    type: float
    vlen: fft_size
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: args
    bb_gain0: '20'
    freq0: freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rxPort
  id: parameter
  parameters:
    label: RX Port
    short_id: r
    type: intx
    value: '2000'
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: '"tcp://0.0.0.0:"+str(ctlPort)'
    bind: 'True'
    timeout: '100'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_nlog10_ff_0, '0', network_tcp_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [zeromq_pull_msg_source_0, out, blocks_msgpair_to_var_0, inpair]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
